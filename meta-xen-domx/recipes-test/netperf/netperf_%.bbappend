# Use latest version with MIT license
SRCREV = "3bc455b23f901dae377ca0a558e1e32aa56b31c4"
LICENSE = "MIT"
LICENSE_FLAGS = "commercial"
LIC_FILES_CHKSUM = "file://COPYING;md5=e661ab33a2a71ad6652c178dedf8aaa2"

